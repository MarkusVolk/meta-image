PACKAGECONFIG:append = " pango rsvg lzma"

