BOOST_LIBS:append = " stacktrace"
