PACKAGECONFIG:append:class-target = " cups iso-codes colord tracker cloudproviders"
