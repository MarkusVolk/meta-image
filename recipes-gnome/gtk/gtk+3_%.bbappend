PACKAGECONFIG:append:class-target = " cups colord cloudproviders tracker3"
