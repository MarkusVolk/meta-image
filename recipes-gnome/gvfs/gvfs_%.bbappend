PACKAGECONFIG:append = " archive dnssd gcrypt gcr samba fuse logind libgphoto2 nfs goa google http"

DEPENDS += "libusb1 libnfs gnome-keyring libgdata gnome-online-accounts"
