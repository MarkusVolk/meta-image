PACKAGECONFIG:append = " nautilus search-provider"
