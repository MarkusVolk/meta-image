PACKAGECONFIG:append = " stemming"
