inherit ccache

PACKAGECONFIG:append = " lcms gles2 bubblewrap media-recorder geoclue enchant libsecret webrtc journald gamepad"
