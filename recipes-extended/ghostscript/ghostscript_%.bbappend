PACKAGECONFIG:append = " gtk libidn"
