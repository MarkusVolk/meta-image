PCI_CONF_FLAG = "DNS=yes SHARED=yes STRIP= LIBDIR=${libdir}"
