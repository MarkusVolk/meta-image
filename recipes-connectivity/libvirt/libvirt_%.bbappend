PACKAGECONFIG:append = " sasl vbox esx polkit"
